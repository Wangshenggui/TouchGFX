# Keil uVision project TouchGFX.uvprojx, settings and files
target TouchGFX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: TouchGFX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,USE_USB_FS,rvmdk PART_LM4F232H5QD TARGET_IS_BLIZZARD_RA1 LM4F232,ARM_MATH_CM7
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../APP/SDRAM;../SYSTEM;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../APP/TOUCH;../Driver-Layer/Backlight;../Driver-Layer/Voice;../Driver-Layer/Radio;../APP/SDMMC;../FATFS/src;../APP/SPI;../APP/W25QXX;../APP/24CXX;../FATFS/APP;../MALLOC;../USB/STM32_USB_Device_Library/Core/Inc;../USB/STM32_USB_Device_Library/Class/MSC/Inc;../USB/USB_APP;../USB/USB_HAL;../APP/NAND;../APP/ADC;../APP/PICTURE;../T9INPUT;../TouchGFX/gui/src/GlobalVariable_Public;../TouchGFX/gui/include/gui/GlobalVariable_Public;../TouchGFX/gui/include/gui/bootscreen_screen;../USMART;../NES/mapper;../NES;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ..\Core\Inc;../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x90000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: TouchGFX\TouchGFX.sct
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c crc.c dma.c dma2d.c fmc.c iwdg.c ltdc.c ramecc.c rng.c rtc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group APP
    ../APP/TOUCH/: ctiic.c ft5206.c
    ../APP/W25QXX/: w25qxx.c
    ../APP/SPI/: spi2.c
    ../APP/24CXX/: 24cxx.c myiic.c
    ../APP/ADC/: my_adc.c
    ../APP/PICTURE/: bmp.c
  group SYSTEM
    ../SYSTEM/: sys.c delay.c usart_it.c tim_it.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c usmart_cmd_input.c
  group FatFs
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/APP/: myFatFs.c
  group USB_CORE
    ../USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_storage.c
  group USB_HAL
    ../USB/USB_HAL/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group NES
    ../NES/: InfoNES_system.c rom.c InfoNES.cpp InfoNES_Mapper.cpp InfoNES_pAPU.cpp K6502.cpp
  group DriverLayer
    ../Driver-Layer/Backlight/: Backlight.c
    ../Driver-Layer/Voice/: Voice.c
    ../Driver-Layer/Radio/: Radio.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/containers/: bookstarcontainer.cpp coordinateconversion.cpp coordinatedotcontainer.cpp filemanagercontainer.cpp keyboardcontainer.cpp navigationbarcontainer.cpp nescontainer.cpp notificationbarcontainer.cpp seedcontainer.cpp setup4gcontainer1.cpp setup4gcontainer2.cpp statusbarcontainer.cpp t9_input.cpp
    ../touchgfx/gui/src/bootscreen_screen/: bootscreenpresenter.cpp bootscreenview.cpp
    ../touchgfx/gui/src/common/scrollingwheels/: clickablecontainer.cpp particlesscrollingwheel.cpp scrollingmenu.cpp scrollingwheel.cpp sparsecontainerlist.cpp touchforwarder.cpp
    ../touchgfx/gui/src/desktopscreen_screen/: desktopscreenpresenter.cpp desktopscreenview.cpp
    ../touchgfx/gui/src/filemanagerscreen_screen/: filemanagerscreenpresenter.cpp filemanagerscreenview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp particleeffect.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/motiontrailscreen_screen/: motiontrailscreenpresenter.cpp motiontrailscreenview.cpp
    ../touchgfx/gui/src/nesscreen_screen/: nesscreenpresenter.cpp nesscreenview.cpp
    ../touchgfx/gui/src/paddysowingscreen_screen/: paddysowingscreenpresenter.cpp paddysowingscreenview.cpp
    ../touchgfx/gui/src/radiosscom_screen_screen/: radiosscom_screenpresenter.cpp radiosscom_screenview.cpp
    ../touchgfx/gui/src/rtkconfigurationscreen_screen/: rtkconfigurationscreenpresenter.cpp rtkconfigurationscreenview.cpp
    ../touchgfx/gui/src/screen_4gmodulesetup_screen/: screen_4gmodulesetuppresenter.cpp screen_4gmodulesetupview.cpp
    ../touchgfx/gui/src/settingscreen_screen/: settingscreenpresenter.cpp settingscreenview.cpp
    ../touchgfx/gui/src/slavecontrolscreen_screen/: slavecontrolscreenpresenter.cpp slavecontrolscreenview.cpp
    ../touchgfx/gui/src/usbinterconnectionscreen_screen/: usbinterconnectionscreenpresenter.cpp usbinterconnectionscreenview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_iconfont_25_1bpp_28.cpp font_iconfont_25_1bpp_29.cpp font_iconfont_42_1bpp_28.cpp font_iconfont_42_1bpp_29.cpp font_misansvf_20_1bpp_0.cpp font_misansvf_20_1bpp_10.cpp font_misansvf_20_1bpp_11.cpp font_misansvf_20_1bpp_12.cpp font_misansvf_20_1bpp_13.cpp font_misansvf_20_1bpp_14.cpp font_misansvf_20_1bpp_15.cpp font_misansvf_20_1bpp_17.cpp font_misansvf_20_1bpp_18.cpp font_misansvf_20_1bpp_19.cpp font_misansvf_20_1bpp_31.cpp font_misansvf_20_1bpp_9.cpp font_misansvf_24_1bpp_0.cpp font_misansvf_24_1bpp_10.cpp font_misansvf_24_1bpp_11.cpp font_misansvf_24_1bpp_12.cpp font_misansvf_24_1bpp_13.cpp font_misansvf_24_1bpp_14.cpp font_misansvf_24_1bpp_15.cpp font_misansvf_24_1bpp_16.cpp font_misansvf_24_1bpp_17.cpp font_misansvf_24_1bpp_18.cpp font_misansvf_24_1bpp_19.cpp font_misansvf_24_1bpp_31.cpp font_misansvf_24_1bpp_9.cpp font_misansvf_30_1bpp_0.cpp font_misansvf_30_1bpp_10.cpp font_misansvf_30_1bpp_11.cpp font_misansvf_30_1bpp_12.cpp font_misansvf_30_1bpp_13.cpp font_misansvf_30_1bpp_14.cpp font_misansvf_30_1bpp_15.cpp font_misansvf_30_1bpp_16.cpp font_misansvf_30_1bpp_17.cpp font_misansvf_30_1bpp_18.cpp font_misansvf_30_1bpp_19.cpp font_misansvf_30_1bpp_31.cpp font_misansvf_30_1bpp_4.cpp font_misansvf_30_1bpp_6.cpp font_misansvf_30_1bpp_9.cpp font_misansvf_40_1bpp_0.cpp font_misansvf_40_1bpp_15.cpp font_misansvf_40_1bpp_17.cpp font_misansvf_60_1bpp_0.cpp font_verdana_20_1bpp_0.cpp font_verdana_25_1bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_iconfont_25_1bpp.cpp kerning_iconfont_42_1bpp.cpp kerning_misansvf_20_1bpp.cpp kerning_misansvf_24_1bpp.cpp kerning_misansvf_30_1bpp.cpp kerning_misansvf_40_1bpp.cpp kerning_misansvf_60_1bpp.cpp kerning_verdana_20_1bpp.cpp kerning_verdana_25_1bpp.cpp table_iconfont_25_1bpp.cpp table_iconfont_42_1bpp.cpp table_misansvf_20_1bpp.cpp table_misansvf_24_1bpp.cpp table_misansvf_30_1bpp.cpp table_misansvf_40_1bpp.cpp table_misansvf_60_1bpp.cpp table_verdana_20_1bpp.cpp table_verdana_25_1bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/containers/: bookstarcontainerbase.cpp coordinatedotcontainerbase.cpp filemanagercontainerbase.cpp keyboardcontainerbase.cpp navigationbarcontainerbase.cpp nescontainerbase.cpp notificationbarcontainerbase.cpp seedcontainerbase.cpp setup4gcontainer1base.cpp setup4gcontainer2base.cpp statusbarcontainerbase.cpp
    ../touchgfx/generated/gui_generated/src/bootscreen_screen/: bootscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/desktopscreen_screen/: desktopscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/filemanagerscreen_screen/: filemanagerscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/notificationbarcontainer/: image__brightness.cpp image_backlight.cpp image_brightness1.cpp image_brightness2.cpp
    ../touchgfx/generated/images/src/nescontainer/: image_a.cpp image_b.cpp image_fangxiang.cpp image_select.cpp image_start.cpp
    ../touchgfx/generated/images/src/keyboardcontainer/: image_back.cpp image_back1.cpp image_china.cpp image_f.cpp image_f1.cpp image_huise.cpp image_jiu.cpp image_jiu1.cpp image_number.cpp image_number1.cpp image_shift.cpp image_shift1.cpp image_space.cpp image_space1.cpp image_write.cpp
    ../touchgfx/generated/images/src/statusbarcontainer/: image_battery_bl.cpp image_ventilatingfanoff.cpp image_ventilatingfanon.cpp
    ../touchgfx/generated/images/src/__designer/: image_blue_pageindicator_dot_indicator_small_highlight.cpp image_blue_pageindicator_dot_indicator_small_normal.cpp image_blue_progressindicators_bg_medium_progress_indicator_bg_square_0_degrees.cpp image_blue_togglebars_toggle_re_small_button_off.cpp image_blue_togglebars_toggle_re_small_button_on.cpp image_dark_icons_back_arrow_48.cpp image_dark_icons_next_arrow_48.cpp image_dark_radio_buttons_radio_round_button_active.cpp
    ../touchgfx/generated/images/src/paddysowingscreen/: image_canshu1.cpp image_canshu2.cpp image_error.cpp image_exit.cpp image_fenxi.cpp image_fenxi1.cpp image_shuju.cpp image_shuju1.cpp
    ../touchgfx/generated/images/src/setting/: image_clock0.cpp image_clock1.cpp image_guayu.cpp image_guayu1.cpp image_reset.cpp image_reset1.cpp image_rili.cpp image_rili1.cpp image_surf.cpp image_surf1.cpp image_updata.cpp image_updata1.cpp
    ../touchgfx/generated/images/src/usbinterconnectionscreen/: image_concatenate.cpp image_disconnect.cpp image_transfer.cpp
    ../touchgfx/generated/images/src/screen_4gmodulesetup/: image_date_picker_background.cpp image_date_picker_bar.cpp image_date_picker_shadow_bottom.cpp image_date_picker_shadow_top.cpp
    ../touchgfx/generated/images/src/filemanagerscreen/: image_file.cpp image_paper_file.cpp image_right.cpp
    ../touchgfx/generated/images/src/desktop/: image_files.cpp image_motor.cpp image_plane.cpp image_seamless-1082217_1280.cpp image_settings.cpp image_usb.cpp
    ../touchgfx/generated/images/src/musicscreen/: image_music.cpp
    ../touchgfx/generated/images/src/particle/: image_particle00.cpp image_particle01.cpp image_particle02.cpp image_particle03.cpp image_particle04.cpp image_particle05.cpp image_particle06.cpp image_particle07.cpp image_particle08.cpp image_particle09.cpp image_particle10.cpp
    ../touchgfx/generated/images/src/qianyulogo/: image_qianyulogo.cpp
    ../touchgfx/generated/images/src/rtk_configurationscreen/: image_rtkback.cpp
    ../touchgfx/generated/images/src/motiontrailscreen/: image_zoomin.cpp image_zoomout.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/motiontrailscreen_screen/: motiontrailscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/nesscreen_screen/: nesscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/paddysowingscreen_screen/: paddysowingscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/radiosscom_screen_screen/: radiosscom_screenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/rtkconfigurationscreen_screen/: rtkconfigurationscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen_4gmodulesetup_screen/: screen_4gmodulesetupviewbase.cpp
    ../touchgfx/generated/gui_generated/src/settingscreen_screen/: settingscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/slavecontrolscreen_screen/: slavecontrolscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/usbinterconnectionscreen_screen/: usbinterconnectionscreenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 5.0.1
